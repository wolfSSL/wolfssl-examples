# Configure curl with wolfProvider support

require ${WOLFSSL_LAYERDIR}/inc/curl/curl-enable-wolfprovider-fips.inc
