# Configure gnupg for libgcrypt with wolfSSL backend

require ${WOLFSSL_LAYERDIR}/inc/gnupg/gnupg-enable-libgcrypt-wolfssl.inc
