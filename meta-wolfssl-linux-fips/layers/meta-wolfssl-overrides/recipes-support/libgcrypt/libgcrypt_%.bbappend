# Configure libgcrypt to use wolfSSL backend

require ${WOLFSSL_LAYERDIR}/inc/libgcrypt/libgcrypt-enable-wolfssl.inc
