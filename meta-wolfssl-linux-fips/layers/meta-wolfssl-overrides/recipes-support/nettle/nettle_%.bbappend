# nettle 3.10 required for gnutls 3.8.11

require ${WOLFSSL_LAYERDIR}/inc/nettle/nettle.inc
