# Configure gnutls to use wolfSSL backend

require ${WOLFSSL_LAYERDIR}/inc/gnutls/gnutls-enable-wolfssl.inc
