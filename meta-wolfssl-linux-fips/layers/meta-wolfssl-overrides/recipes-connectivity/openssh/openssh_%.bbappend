# OpenSSH ptest modifications for wolfProvider FIPS testing

require ${WOLFSSL_LAYERDIR}/inc/wolfprovider/openssh/openssh-enable-wolfprovider.inc
