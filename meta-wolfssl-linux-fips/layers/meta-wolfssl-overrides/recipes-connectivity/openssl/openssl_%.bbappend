# Configure OpenSSL to use wolfProvider in replace-default mode

require ${WOLFSSL_LAYERDIR}/inc/wolfprovider/openssl/openssl-enable-wolfprovider-replace-default.inc
